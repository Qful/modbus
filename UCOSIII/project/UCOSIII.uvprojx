# Keil uVision project UCOSIII.uvprojx, settings and files
target ucosiii (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407IG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: UCOSIII
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\APP;..\BSP;..\CM4;..\modbus\functions;..\modbus\include;..\modbus\Modbus-Task;..\modbus\Port;..\modbus\rtu;..\ST_LIB\inc;..\ST_LIB\src;..\uC-CPU;..\uC-LIB;..\uCOS-III\Ports;..\uC-Serial;..\uCOS-III\Source;..\User
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group APP
    ../APP/: app.c app_cfg.h app_serial.c app_serial.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h stm32f4xx.h stm32f4xx_conf.h
  group BSP
    ../BSP/: bsp.c bsp.h bsp_int.c bsp_os.c bsp_os.h bsp_periph.c cstartup.s typedefine.h
  group CM4
    ../CM4/: core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h
  group MODBUS
    ../modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ../modbus/include/: mb.h mbconfig.h mbframe.h mbfunc.h mbport.h mbproto.h mbutils.h
    ../modbus/Modbus-Task/: TaskModbus.c TaskModbus.h
    ../modbus/Port/: port.c port.h portevent.c portserial.c porttimer.c
    ../modbus/rtu/: mbcrc.c mbcrc.h mbrtu.c mbrtu.h
    ../modbus/: mb.c
  group ST_LIB
    ../ST_LIB/inc/: misc.h stm32f4xx_adc.h stm32f4xx_can.h stm32f4xx_crc.h stm32f4xx_cryp.h stm32f4xx_dac.h stm32f4xx_dbgmcu.h stm32f4xx_dcmi.h stm32f4xx_dma.h stm32f4xx_exti.h stm32f4xx_flash.h stm32f4xx_fsmc.h stm32f4xx_gpio.h stm32f4xx_hash.h stm32f4xx_i2c.h stm32f4xx_iwdg.h stm32f4xx_pwr.h stm32f4xx_rcc.h stm32f4xx_rng.h stm32f4xx_rtc.h stm32f4xx_sdio.h stm32f4xx_spi.h stm32f4xx_syscfg.h stm32f4xx_tim.h stm32f4xx_usart.h stm32f4xx_wwdg.h
    ../ST_LIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group UC_CPU
    ../uC-CPU/: cpu.h cpu_a.asm cpu_c.c cpu_core.c cpu_core.h cpu_def.h
  group UC_LIB
    ../uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_mem_a.asm lib_str.c lib_str.h
  group UCOS_III
    ../uCOS-III/Ports/: os_cpu.h os_cpu_a.asm os_cpu_c.c
    ../uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
  group UC_SERIAL
    ../uC-Serial/: serial.c serial.h serial_bsp_stm3240x.c serial_bsp_stm3240x.h serial_buf.c serial_buf.h serial_drv_stm32.c serial_drv_stm32.h serial_line_dflt.c serial_line_dflt.h serial_line_probe.c serial_line_probe.h serial_line_tty.c serial_line_tty.h serial_os.c serial_os.h serial_type.h
  group USER
    ../User/: TaskOne.c TaskTwo.c
software components: CMSIS:CORE 5.0.1
